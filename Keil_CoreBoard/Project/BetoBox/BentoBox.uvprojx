# Keil uVision project BentoBox.uvprojx, settings and files
target BentoBox (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: M2S010 Microsemi
  pack: Microsemi.M2Sxxx.1.0.61
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BentoBox +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\uC-CPU;..\..\uC-CPU\ARM-Cortex-M3\RealView;..\..\uCOS-III\Source;..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\BSP;..\..\uC-LIB;..\..\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\APP;.\BSP\OS\uCOS-III;.\Lib\Header
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\RTE\Device\M2S010\smartfusion2_execute_in_place.sct
  group APP
    ./APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ./BSP/: bsp.c bsp.h vcp_app.c vcp_app.h usb_user_descriptors.c isr.c BusApis.c BusApis.h
    ./BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group uC-LIB
    ../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC_CPU
    ../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uCOS-III Ports
    ../../uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS-III Source
    ../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os.h os_type.h
  group LIB
    ./Lib/Header/: core_gpio.h core_i2c.h core_irq_ctrl.h core_smbus_regs.h core_spi.h core_uart_apb.h coregpio_regs.h coreinterrupt_regs.h corespi_regs.h coreuartapb_regs.h cortex_nvic.h cpu_types.h hal.h hal_assert.h hw_macros.h hw_reg_access.h hw_reg_io.h M2sExt_hw_platform.h m2sxxx.h mss_assert.h mss_comblk.h mss_comblk_page_handler.h mss_hpdma.h mss_nvm.h mss_pdma.h mss_sys_services.h mss_timer.h mss_usb_common_cif.h mss_usb_common_reg_io.h mss_usb_config.h mss_usb_core_regs.h mss_usb_device.h mss_usb_device_cdc.h mss_usb_device_cif.h mss_usb_device_hid.h mss_usb_device_msd.h mss_usb_device_printer.h mss_usb_device_reg_io.h mss_usb_device_vendor.h mss_usb_host.h mss_usb_host_cif.h mss_usb_host_msc.h mss_usb_host_reg_io.h mss_usb_std_def.h mss_watchdog.h sys_config.h sys_config_mss_clocks.h sys_init_cfg_types.h system_m2sxxx.h
    C:/Users/AndersonHan/Desktop/BentoBox/Fpga/Keil/obj/: M2sExt_sb_MSS_CM3_hw_platform.lib
