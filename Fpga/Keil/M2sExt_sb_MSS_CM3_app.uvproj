# Keil uVision project M2sExt_sb_MSS_CM3_app.uvproj, settings and files
target Cortex-M3 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: M2S010 Actel
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x00000000-0x0003FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: M2sExt_sb_MSS_CM3_app
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ./;./CMSIS;./CMSIS/startup_arm;./drivers;./drivers/CoreGPIO;./drivers/CoreI2C;./drivers/CoreInterrupt;./drivers/CoreSPI;./drivers/CoreUARTapb;./drivers/mss_hpdma;./drivers/mss_nvm;./drivers/mss_pdma;./drivers/mss_sys_services;./drivers/mss_timer;./drivers/mss_usb;./drivers/mss_watchdog;./drivers_config;./drivers_config/sys_config;./hal;./hal/CortexM3;./hal/CortexM3/Keil
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x1000000
  memory RVCT6: RAM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ./CMSIS/startup_arm/smartfusion2_execute_in_place.sct
  group Source Files
    ./: main.c
  group Library Files
    ./obj/: M2sExt_sb_MSS_CM3_hw_platform.lib
target Cortex-M3 SRAM (ARM-ADS)
  device: M2S010 Actel
  cpu: as above
  output: M2sExt_sb_MSS_CM3_app
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  scatter file: ./CMSIS/startup_arm/smartfusion2_execute_in_place.sct
