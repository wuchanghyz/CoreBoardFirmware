# Keil uVision project M2sExt_sb_MSS_CM3_hw_platform.uvproj, settings and files
target Cortex-M3 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: M2S010 Actel
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x00000000-0x0003FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: M2sExt_sb_MSS_CM3_hw_platform (library)
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ./;./CMSIS;./CMSIS/startup_arm;./drivers;./drivers/CoreGPIO;./drivers/CoreI2C;./drivers/CoreInterrupt;./drivers/CoreSPI;./drivers/CoreUARTapb;./drivers/mss_hpdma;./drivers/mss_nvm;./drivers/mss_pdma;./drivers/mss_sys_services;./drivers/mss_timer;./drivers/mss_usb;./drivers/mss_watchdog;./drivers_config;./drivers_config/sys_config;./hal;./hal/CortexM3;./hal/CortexM3/Keil
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    CMSIS/startup_arm/: low_level_init.c retarget.c startup_m2sxxx.s
    CMSIS/: system_m2sxxx.c
  group Headers
    CMSIS/: hw_reg_io.h m2sxxx.h mss_assert.h sys_init_cfg_types.h system_m2sxxx.h
    ./: M2sExt_hw_platform.h
    drivers/CoreGPIO/: core_gpio.h coregpio_regs.h
    drivers/CoreI2C/: core_i2c.h core_smbus_regs.h
    drivers/CoreInterrupt/: core_irq_ctrl.h coreinterrupt_regs.h
    drivers/CorePWM/: core_pwm.h corepwm_regs.h
    drivers/CoreSPI/: core_spi.h corespi_regs.h
    drivers/CoreUARTapb/: core_uart_apb.h coreuartapb_regs.h
    drivers/mss_hpdma/: mss_hpdma.h
    drivers/mss_nvm/: mss_nvm.h
    drivers/mss_pdma/: mss_pdma.h
    drivers/mss_sys_services/: mss_comblk.h mss_comblk_page_handler.h mss_sys_services.h
    drivers/mss_timer/: mss_timer.h
    drivers/mss_usb/: mss_usb_common_cif.h mss_usb_common_reg_io.h mss_usb_config.h mss_usb_core_regs.h mss_usb_device.h mss_usb_device_cdc.h mss_usb_device_cif.h mss_usb_device_hid.h mss_usb_device_msd.h mss_usb_device_printer.h mss_usb_device_reg_io.h mss_usb_device_vendor.h mss_usb_host.h mss_usb_host_cif.h mss_usb_host_msc.h mss_usb_host_reg_io.h mss_usb_std_def.h
    drivers/mss_watchdog/: mss_watchdog.h
    drivers_config/sys_config/: sys_config.h sys_config_mss_clocks.h
    hal/CortexM3/Keil/: cpu_types.h hw_macros.h
    hal/CortexM3/: cortex_nvic.h
    hal/: hal.h hal_assert.h hw_reg_access.h
  group drivers
    drivers/CoreGPIO/: core_gpio.c
    drivers/CoreI2C/: core_i2c.c i2c_interrupt.c
    drivers/CoreInterrupt/: core_irq_ctrl.c
    drivers/CorePWM/: core_pwm.c
    drivers/CoreSPI/: core_spi.c
    drivers/CoreUARTapb/: core_uart_apb.c
    drivers/mss_hpdma/: mss_hpdma.c
    drivers/mss_nvm/: mss_nvm.c
    drivers/mss_pdma/: mss_pdma.c
    drivers/mss_sys_services/: mss_comblk.c mss_sys_services.c
    drivers/mss_usb/: mss_usb_common_cif.c mss_usb_device.c mss_usb_device_cdc.c mss_usb_device_cif.c mss_usb_device_hid.c mss_usb_device_msd.c mss_usb_device_printer.c mss_usb_device_vendor.c mss_usb_host.c mss_usb_host_cif.c mss_usb_host_msc.c
  group drivers_config
    drivers_config/sys_config/: sys_config.c
  group hal
    hal/CortexM3/Keil/: hal.s hw_reg_access.s
    hal/CortexM3/: cortex_nvic.c
target Corttex-M3 SRAM (ARM-ADS)
  device: M2S010 Actel
  cpu: as above
  output: M2sExt_sb_MSS_CM3_hw_platform (library)
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
